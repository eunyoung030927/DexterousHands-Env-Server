Commit message: backup2

File: assets/mjcf/bottle_cap/mobility.urdf (robot description, URDF)
Before this commit: robot partnet_f0a5f6d2cf8fcb72c12d8e00a78db6e2, 4 links, 3 joints
Joints:
- joint joint_2: mimic (none) -> joint=joint_0 multiplier=0.002 offset=0
